SUMMARY = "BarreleyeG2 board wiring"
DESCRIPTION = "Board wiring information for the BarreleyeG2 system."
PR = "r1"

inherit config-in-skeleton
