EXTRA_OECMAKE_append_df-openpower = " \
    -DBMCWEB_ENABLE_REDFISH_DBUS_LOG_ENTRIES=ON \
    -DBMCWEB_ENABLE_LOGGING_MW=ON \
    -DBMCWEB_INSECURE_ENABLE_REDFISH_FW_TFTP_UPDATE=ON \
    "
